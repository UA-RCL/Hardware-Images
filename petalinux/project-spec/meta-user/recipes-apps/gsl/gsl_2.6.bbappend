# We don't actually want to modify anything about the libgsl sources
# We just want to include the static "libgsl.a" in the build
DISABLE_STATIC = ""

